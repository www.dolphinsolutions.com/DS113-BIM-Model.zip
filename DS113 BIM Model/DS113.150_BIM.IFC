Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DS113.150_BIM.IFC
Time: 2020-05-26T12:47:38
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: DS113.150_BIM
In: Default Storey
Material: Steel
